options:
  parameters:
    generate_options: qt_gui
    id: Combined_mp_csb
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: FRx
  id: variable
  parameters:
    value: 2*FTx-RxShift
  states: {}
- name: FTx
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: Fm
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: GRx
  id: variable_qtgui_entry
  parameters:
    label: Receive Gain
    type: real
    value: '35'
  states: {}
- name: GTx
  id: variable_qtgui_entry
  parameters:
    label: Transmit Gain
    type: real
    value: '60'
  states: {}
- name: G_Sweep
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: 'Sweep Gain:'
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: Length
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Mod_ind
  id: variable_qtgui_entry
  parameters:
    label: Mod Index <=1, 0 to Disable
    type: real
    value: '0'
  states: {}
- name: RxShift
  id: variable
  parameters:
    value: 0.2e6
  states: {}
- name: StartSwp
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Sweep Phase
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: Track
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Start/Stop Tracking
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: prefix
  id: variable_qtgui_entry
  parameters:
    label: File Name
    type: string
    value: Date_Test
  states: {}
- name: samp_rate_src
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: 0.5*Mod_ind
    freq: Fm
    offset: '0.5'
    phase: '0'
    samp_rate: samp_rate_src
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_src/Decimation
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Length
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Length
  states: {}
- name: blocks_complex_to_mag_squared_0_1_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: Length
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-1*(RxShift)'
    sample_rate: samp_rate_src
  states: {}
- name: blocks_freqshift_cc_0_0
  id: blocks_freqshift_cc
  parameters:
    freq: '-1*RxShift'
    sample_rate: samp_rate_src
  states: {}
- name: blocks_max_xx_1_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: Length
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_1_1_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: Length
    vlen_out: '1'
  states: {}
- name: blocks_max_xx_1_1_0_0
  id: blocks_max_xx
  parameters:
    type: float
    vlen: Length
    vlen_out: '1'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '100'
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '2'
    max_iter: 2*Length
    scale: '0.5'
    type: float
    vlen: Length
  states: {state: bypassed}
- name: blocks_msgpair_to_var_1
  id: blocks_msgpair_to_var
  parameters:
    target: GTx
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/Length
    type: complex
    vlen: Length
  states: {}
- name: blocks_multiply_const_xx_0_2
  id: blocks_multiply_const_xx
  parameters:
    const: 1/1024
    type: complex
    vlen: Length
  states: {}
- name: blocks_multiply_const_xx_0_2_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1/1024
    type: complex
    vlen: Length
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: Length
  states: {}
- name: blocks_nlog10_ff_0_2
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: Length
  states: {}
- name: blocks_nlog10_ff_0_2_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: Length
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: '0'
  states: {}
- name: blocks_phase_shift_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: '0'
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Length
    type: float
  states: {}
- name: blocks_stream_to_vector_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: Length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_2_0
  id: blocks_stream_to_vector
  parameters:
    num_items: Length
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_2
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_2_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, inVecSize=1024, f1_ind=50,f2_ind=50,f3_ind=50,searchSize =10):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='ThreeMax',   # will show up in GRC\n            in_sig=[(np.float32,inVecSize)],#(gr.sizeof_float*1)],\n            out_sig=[(np.float32,3)]    \n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.f1_ind= f1_ind\n        self.f2_ind= f2_ind\n        self.f3_ind= f3_ind\n        self.inVecSize = inVecSize\n        self.searchSize = searchSize\n \n\n    def work(self, input_items, output_items):\n\n        P1 = np.max( input_items[0][0][(self.f1_ind-self.searchSize):(self.f1_ind+self.searchSize)])\n        P2 = np.max( input_items[0][0][(self.f2_ind-self.searchSize):(self.f2_ind+self.searchSize)])\n        P3 = np.max( input_items[0][0][(self.f3_ind-self.searchSize):(self.f3_ind+self.searchSize)])\n\n        top3 =np.array([P1,P2,P3])\n        # print(top3)\n        # vals = sorted_vec[:3]\n        # #print(vals)\n        # output_items[0][:]= vals\n        output_items[0][:]= top3\n\n        return len(output_items[0])\n\n"
    f1_ind: int((-1*Fm)*Length/(samp_rate_src/Decimation))+int(Length/2)
    f2_ind: int(Length/2)
    f3_ind: int((Fm)*Length/(samp_rate_src/Decimation))+int(Length/2)
    inVecSize: Length
    searchSize: '80'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    BW: 1e3
    CenterFreq: 1.83e9
    Length: Length
    SignalFreq: 1.83e9
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class PhaseDiff(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, Length = 1024,CenterFreq = 0,SignalFreq = 0,BW=0,samp_rate = 1000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Calculate Phase Shift',   # will show up in GRC
                  in_sig=[(np.complex64, Length),(np.complex64, Length)],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              
              self.signal_ind = int((Length/samp_rate)*(SignalFreq-CenterFreq)+Length/2)
              self.Start = int((Length/samp_rate)*(SignalFreq-CenterFreq-BW)+Length/2)
              print("Start Index: ",self.Start,"\n")
              self.End = int((Length/samp_rate)*(SignalFreq-CenterFreq+BW)+Length/2)
              print("Stop Index: ",self.End,"\n")
              self.Length =Length
              self.CenterFreq = CenterFreq
              self.SignalFreq = SignalFreq
              self.BW = BW
              self.samp_rate = samp_rate

          def work(self, input_items, output_items):
              #print("In0 size FFT @ f0:   ",np.shape(input_items[0][0][self.Start:self.End]),"\n")
              #print("In1 size FFT @ f0:   ",np.shape(input_items[1][0][self.Start:self.End]),"\n")
              if self.BW!=0:
                  crltn = np.correlate(input_items[0][0][self.Start:self.End],input_items[1][0][self.Start:self.End])
              else:
                  crltn = input_items[0][0][self.Start]*input_items[1][0][self.Start]
              #crltn = np.correlate(input_items[0][0][self.signal_ind],input_items[1][0][self.signal_ind])

              diff = np.angle(crltn)
             
              output_items[0][:] = diff

              return len(output_items[0])
    samp_rate: samp_rate_src/Decimation
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass CSB_calc(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self,):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='C/SB Calculator',   # will show up in GRC\n            in_sig=[(np.float32,3)],\n            out_sig=[np.float32,np.float32,np.float32,np.float32]    \n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n\n\n    def work(self, input_items, output_items):\n        LSB = input_items[0][0][0]\n        C = input_items[0][0][1]\n        RSB = input_items[0][0][2]\n\n        # if abs(RSB-LSB)>2:\n        #     print(\"\\nWarning: Right sideband exceeds left by \",(RSB-LSB),\" dB\\n\") \n        \n        SB_avg = (LSB+RSB)/2\n        CSB = C-SB_avg\n\n        output_items[0][:] = CSB\n        output_items[1][:] =LSB\n        output_items[2][:] = C\n        output_items[3][:] = RSB\n\n        return len(output_items[0])\n\n"
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    Spacing: '1'
    Track: Track
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class Tracker(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Controller to track signal by minimizing monopulse ratio. Input 1 should be the log magnitude of the monopulse
          ratio and Input 2 the phase shift between difference and sum. Input message (Ts) determines when
          controller is updated and should be polled regularly, actual message content is irrelevant. 
          Output phase is in radians and computed tracking angle in degrees, formatted for az/el sink.

          \n Inputs:
          \n Track - Boolean to activate/deactivate tracking
          \n Spacing - Element spacing in wavelengths 
          """

          def __init__(self, Track = False,Spacing = 1,alpha = 0.1 ):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Tracking Controller',   # will show up in GRC
                  in_sig=[np.float32,np.float32],
                  out_sig=None
              )

              self.message_port_register_out(pmt.intern('phase'))
              self.message_port_register_out(pmt.intern('az'))
              self.message_port_register_out(pmt.intern('Lock'))
              self.message_port_register_out(pmt.intern('steer_angle'))

              self.message_port_register_in(pmt.intern('Ts'))

              self.set_msg_handler(pmt.intern('Ts'), self.handle_msg)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.Track = Track
              self.phase = 0          # Phase shift applied to steer beam
              self.Lock = False
              self.Spacing = Spacing
              #self.Tolerance = Tolerance
              #self.null = null
              self.mp1 = 100
              self.alpha = alpha  
              
          def handle_msg(self,msg):
              ang_deg = np.rad2deg(np.arcsin(self.phase/(2*np.pi*self.Spacing)))
              self.message_port_pub(pmt.intern("az"), pmt.cons(pmt.to_pmt({"az": ang_deg, "el": 0}),pmt.to_pmt(None)))

              if self.Track:
                  self.message_port_pub(pmt.intern("phase"), pmt.cons(pmt.intern("shift"),pmt.to_pmt(self.phase)))
                  self.message_port_pub(pmt.intern("steer_angle"), pmt.cons(pmt.intern("ampl"),pmt.to_pmt(ang_deg)))
                  self.message_port_pub(pmt.intern("Lock"), pmt.cons(pmt.intern("ampl"),pmt.to_pmt(self.Lock)))

                  if self.Lock:
                      print("Target Found")
                  

              return

          def work(self, input_items, output_items):
              if self.Track:

                  self.Lock = False
                  # if (abs(input_items[1][0]) <self.Tolerance)and(input_items[0][0]< self.null):
                  #     self.Lock = True

                  # elif input_items[1][0]<0:
                  #     self.phase = self.phase-0.005
                  # elif input_items[1][0]>0:
                  #     self.phase = self.phase+0.005
                  # if abs(self.phase)>180:
                  #     print("Boundary reached, rotate array")
                  side = np.sign(input_items[1][0])

                  if input_items[0][0]<self.mp1:
                      self.phase +=side*self.alpha
                  self.mp1 = input_items[0][0]

              return len(input_items[0])
    alpha: '0.005'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    Average: '50'
    Prefix: prefix
    Start: '-180'
    Step: '2'
    Stop: '180'
    Sweep: StartSwp
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class MPSweep(gr.sync_block):  
          """Sweep block to sweep phase and measure 4 quantities. Output is saved as two .npy files. 
          _x_out.npy contains the phase for each measurement and _data.npy has the input data stored 
          as a 4xn matrix where each row is the corresponding input. 
          \n Inputs:
          \n Sweep - Boolean, when true, sweep is initiated
          \n Start - Starting Value
          \n Stop - Ending Value
          \n Step - Resolution of sweep
          \n sample_buffer - This sets a number of data-buffers to be discarded in between measurements
          \n Average - Number of measurements to average when saveing data
          \n Prefix - String to append to the start of filename"""

          def __init__(self, Sweep = False,Start = 0,Stop =12,Step = 0.5,sample_buffer=10, Average = 1,Prefix = ""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Sweep Controller 03',   
                  in_sig=[np.float32,np.float32,np.float32,np.float32],

                  out_sig=None
              )


              self.message_port_register_out(pmt.intern('out'))
              
              #self.message_port_register_in(pmt.intern('Value_Set'))
              #self.set_msg_handler(pmt.intern('Value_Set'), self.handle_msg)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).

              inputs = 4   # Used in construction only to define array sizes

              
              self.Sweep = Sweep
              self.Start = Start
              self.Stop = Stop
              self.Step = Step
              self.Average = Average
              self.avgVec = np.empty((inputs,Average))
              #print("avgVec Size",self.avgVec.shape,"\n")
              self.Prefix = Prefix

              

              self.SwpVar = self.Start
              self.state = 0
              self.xAxe = np.arange(self.Start,self.Stop+self.Step,self.Step)
              self.data = np.empty((inputs,len(self.xAxe)))
              #print("data Size",self.data.shape,"\n")

              self.sample_buffer = sample_buffer
              self.counter  = sample_buffer
              self.index = 0


          def work(self, input_items, output_items):


              match self.state:
                  case 0:
                      if self.Sweep == True: #Log initial value
                          self.message_port_pub(pmt.intern("out"), pmt.cons(pmt.intern("shift"),pmt.to_pmt(np.deg2rad(self.SwpVar))))
                          self.counter = self.sample_buffer
                          self.state = 2  

                          print("\nDatapoints: ",len(self.xAxe))
                          print("Size of Output: ",np.shape(self.data))
                          print("Running Sweep... \n")


                  case 1: # Update phase value

                          self.SwpVar += self.Step
                          self.message_port_pub(pmt.intern("out"), pmt.cons(pmt.intern("shift"),pmt.to_pmt(np.deg2rad(self.SwpVar))))
                          self.counter = self.sample_buffer
                          self.state = 2


                  case 2: #Wait for buffer time
                      self.counter -= 1
                      if self.counter < 0:
                          self.state = 5
                          self.counter = self.Average


                  case 5: #Average values
                      self.counter += -1
                      in0 = np.sum(input_items[0])/len(input_items[0])#input_items[0][0]
                      in1 = np.sum(input_items[1])/len(input_items[1])#input_items[1][0]
                      in2 = np.sum(input_items[2])/len(input_items[2])#input_items[2][0]
                      in3 = np.sum(input_items[3])/len(input_items[3])#input_items[3][0]
                      self.avgVec[:,self.counter] = np.array([[in0],[in1],[in2],[in3]])[:,0]

                      if self.counter < 0:
                          self.state = 3

                  case 3: #Log value
                      #print("Phase",self.SwpVar,"\n")
                      #print("Sample Vector: ",self.avgVec,"\n")
                      avg = (np.divide(np.sum(self.avgVec,axis=1),len(self.avgVec[0,:])))
                      #print("Saving value:  ",avg.reshape(4,1),"\n")

                      self.data[:,self.index] = avg.reshape(4,1)[:,0]
                      #print("Saved:  ",self.data[:,self.index],"\n")
                      self.index+=1
                      #print("Index",self.index," of ",len(self.xAxe),"\n")
                      if self.index>=len(self.xAxe):
                          self.state = 4
                      else:
                          self.state = 1

                      
                  case 4: #Write data to files
                      out = np.concatenate((self.xAxe.reshape(1,-1),self.data),axis=0)

                      np.save(f"{self.Prefix}_data.npy",out)

                      print("Data Saved! Sweep Complete \n")
                      
                      self. state = 6

                  case 6: # Wait for sweep to be reinitialized
                      if self.Sweep:
                          pass

                      else:
                          self.SwpVar = self.Start
                          #self.xAxe = np.arange(self.Start,self.Stop+self.Step,self.Step)
                          #self.data = np.empty((inputs,len(self.xAxe)))
                          #self.sample_buffer = sample_buffer
                          #self.counter  = sample_buffer

                          self.index = 0
                          print("Reset! Ready to sweep again\n")
                          self.state = 0
                          
              return len(input_items[0])
    sample_buffer: '10'
  states: {}
- name: epy_block_3_0
  id: epy_block
  parameters:
    Average: '40'
    Prefix: prefix
    Start: '45'
    Step: '0.5'
    Stop: '60'
    Sweep: G_Sweep
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import pmt
      from gnuradio import gr


      class Sweep(gr.sync_block):  
          """Sweep block to sweep gain and measure 4 quantities. Output is saved as two .npy files. 
          _x_out.npy contains the phase for each measurement and _data.npy has the input data stored 
          as a 4xn matrix where each row is the corresponding input. 
          \n Inputs:
          \n Sweep - Boolean, when true, sweep is initiated
          \n Start - Starting Value
          \n Stop - Ending Value
          \n Step - Resolution of sweep
          \n sample_buffer - This sets a number of data-buffers to be discarded in between measurements
          \n Average - Number of measurements to average when saveing data
          \n Prefix - String to append to the start of filename"""

          def __init__(self, Sweep = False,Start = 0,Stop =12,Step = 0.5,sample_buffer=10, Average = 1,Prefix = ""):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Gain Sweep',   
                  in_sig=[np.float32,np.float32,np.float32,np.float32],
                  out_sig=None
              )


              self.message_port_register_out(pmt.intern('out'))
              
              #self.message_port_register_in(pmt.intern('Value_Set'))
              #self.set_msg_handler(pmt.intern('Value_Set'), self.handle_msg)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              inputs = 4   # Used in construction only to define array sizes

              self.Sweep = Sweep
              self.Start = Start
              self.Stop = Stop
              self.Step = Step
              self.Average = Average
              self.avgVec = np.empty((inputs,Average))
              self.Prefix = Prefix

              self.SwpVar = self.Start
              self.state = 0
              self.xAxe = np.arange(self.Start,self.Stop+self.Step,self.Step)
              self.data = np.empty((inputs,len(self.xAxe)))
              self.sample_buffer = sample_buffer
              self.counter  = sample_buffer
              self.index = 0


          def work(self, input_items, output_items):

              match self.state:
                  case 0:
                      if self.Sweep == True: #Log initial value
                          print("\nDatapoints: ",len(self.xAxe))
                          print("Size of Output: ",np.shape(self.data))
                          print("\nRunning Sweep...")
                          self.message_port_pub(pmt.intern("out"), pmt.cons(pmt.intern("gain"),pmt.to_pmt(self.SwpVar)))
                          self.counter = self.sample_buffer
                          self.state = 2  


                  case 1: # Update sweep variable

                          self.SwpVar += self.Step
                          self.message_port_pub(pmt.intern("out"), pmt.cons(pmt.intern("gain"),pmt.to_pmt(self.SwpVar)))
                          self.counter = self.sample_buffer
                          self.state = 2


                  case 2: #Wait for buffer time
                      self.counter -= 1
                      if self.counter < 0:
                          self.state = 5
                          self.counter = self.Average


                  case 5: #Average values
                      self.counter += -1
                      in0 = np.sum(input_items[0])/len(input_items[0])#input_items[0][0]
                      in1 = np.sum(input_items[1])/len(input_items[1])#input_items[1][0]
                      in2 = np.sum(input_items[2])/len(input_items[2])#input_items[2][0]
                      in3 = np.sum(input_items[3])/len(input_items[3])#input_items[3][0]
                      self.avgVec[:,self.counter] = np.array([[in0],[in1],[in2],[in3]])[:,0]

                      if self.counter < 0:
                          self.state = 3

                  case 3: #Log value
                      #print("Gain",self.SwpVar,"\n")
                      #print("Sample Vector: ",self.avgVec,"\n")
                      avg = (np.divide(np.sum(self.avgVec,axis=1),len(self.avgVec[0,:])))
                      #print("Saving value:  ",avg.reshape(4,1),"\n")

                      self.data[:,self.index] = avg.reshape(4,1)[:,0]
                      #print("Saved:  ",self.data[:,self.index],"\n")
                      self.index+=1
                      #print("Index",self.index," of ",len(self.xAxe),"\n")
                      if self.index>=len(self.xAxe):
                          self.state = 4
                      else:
                          self.state = 1

                      
                  case 4: # Write data to file
                      out = np.concatenate((self.xAxe.reshape(1,-1),self.data),axis=0)
                      np.save(f"{self.Prefix}_data.npy",out)

                      print("Data Saved! Sweep Complete \n")
                      self. state = 6

                  case 6: # Wait for sweep to be reinitialized
                      if self.Sweep:
                          pass
                      else:
                          self.SwpVar = self.Start

                          self.index = 0
                          print("Reset! Ready to sweep again\n")
                          self.state = 0

              return len(input_items[0])
    sample_buffer: '5'
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: Length
    forward: 'True'
    shift: 'True'
    type: float
    window: window.blackmanharris(Length)
  states: {}
- name: fft_vxx_0_2
  id: fft_vxx
  parameters:
    fft_size: Length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: fft_vxx_0_2_0
  id: fft_vxx
  parameters:
    fft_size: Length
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: Decimation
    gain: '1'
    samp_rate: samp_rate_src
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: Decimation
    gain: '1'
    samp_rate: samp_rate_src
    type: fir_filter_ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate_src
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    name: Transmitted Signal
    showports: 'True'
    type: float
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_src/Decimation
    fc: 2*FTx
    fftsize: '1024'
    name: '"Monopulse Ratio"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_src/Decimation
    fc: FRx+RxShift
    fftsize: '1024'
    label1: Source 1
    label2: Source 2
    name: '"Inputs"'
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"C/SB"'
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Steering Angle
    type: float
    unit1: degrees
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    name: Sum FFT
    ref_level: '-0'
    showports: 'True'
    vlen: Length
    x_axis_label: '"Frequency [GHz]"'
    x_start: (2*FTx-samp_rate_src/(Decimation*2))*1e-9
    x_step: (samp_rate_src/(Decimation*Length))*1e-9
    x_units: '"GHz"'
    y_axis_label: '"Relative Power [dB]"'
    y_units: '"dB"'
    ymax: '-30'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: FTx
    center_freq1: FTx
    gain0: GTx
    gain1: '-40'
    nchan: '2'
    samp_rate: samp_rate_src
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: FRx
    center_freq1: FRx
    gain0: GRx
    gain1: GRx
    nchan: '2'
    rx_agc0: Disabled
    rx_agc1: Disabled
    samp_rate: samp_rate_src
    sync: sync
    type: fc32
  states: {}
- name: variable_qtgui_azelplot_0
  id: variable_qtgui_azelplot
  parameters: {}
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: Sweep_ph_msg
  states: {}
- name: virtual_sink_10
  id: virtual_sink
  parameters:
    stream_id: Sum_LogMag
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: Diff
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: Sum
  states: {}
- name: virtual_sink_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: Input_1
  states: {}
- name: virtual_sink_1_0_1
  id: virtual_sink
  parameters:
    stream_id: Input_0
  states: {}
- name: virtual_sink_1_1
  id: virtual_sink
  parameters:
    stream_id: Diff_I
  states: {}
- name: virtual_sink_1_1_0
  id: virtual_sink
  parameters:
    stream_id: Sum_I
  states: {}
- name: virtual_sink_1_2
  id: virtual_sink
  parameters:
    stream_id: Diff_Q
  states: {}
- name: virtual_sink_1_2_0
  id: virtual_sink
  parameters:
    stream_id: Sum_Q
  states: {}
- name: virtual_sink_1_3
  id: virtual_sink
  parameters:
    stream_id: Im_Ratio
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Phase_Shift
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: Diff_FFT
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: Sum_FFT
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: Track_ph_msg
  states: {}
- name: virtual_sink_7
  id: virtual_sink
  parameters:
    stream_id: Im_Ratio_LogMag
  states: {}
- name: virtual_sink_9
  id: virtual_sink
  parameters:
    stream_id: Diff_LogMag
  states: {}
- name: virtual_sink_9_0
  id: virtual_sink
  parameters:
    stream_id: Sum_FFT_Mag
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: Sweep_ph_msg
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: Im_Ratio
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: Im_Ratio
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: Track_ph_msg
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: Sum_FFT_Mag
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: Diff
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: Sum
  states: {}
- name: virtual_source_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: Sum
  states: {}
- name: virtual_source_1_0_0_2
  id: virtual_source
  parameters:
    stream_id: Input_1
  states: {}
- name: virtual_source_1_0_0_3
  id: virtual_source
  parameters:
    stream_id: Input_0
  states: {}
- name: virtual_source_1_0_2
  id: virtual_source
  parameters:
    stream_id: Diff
  states: {}
- name: virtual_source_1_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: Sum_I
  states: {}
- name: virtual_source_1_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: Sum_I
  states: {}
- name: virtual_source_1_1_0_2
  id: virtual_source
  parameters:
    stream_id: Sum_I
  states: {}
- name: virtual_source_1_1_1
  id: virtual_source
  parameters:
    stream_id: Diff_Q
  states: {}
- name: virtual_source_1_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: Sum_Q
  states: {}
- name: virtual_source_1_2_0_1_0
  id: virtual_source
  parameters:
    stream_id: Sum_Q
  states: {}
- name: virtual_source_1_2_0_2
  id: virtual_source
  parameters:
    stream_id: Sum_Q
  states: {}
- name: virtual_source_1_2_1
  id: virtual_source
  parameters:
    stream_id: Diff_I
  states: {}
- name: virtual_source_1_3
  id: virtual_source
  parameters:
    stream_id: Phase_Shift
  states: {}
- name: virtual_source_1_4
  id: virtual_source
  parameters:
    stream_id: Phase_Shift
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: Diff_FFT
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: Diff_FFT
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: Sum_FFT
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: Sum_FFT
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: Sum_LogMag
  states: {}
- name: virtual_source_5_0_0
  id: virtual_source
  parameters:
    stream_id: Diff_LogMag
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: Im_Ratio_LogMag
  states: {}
- name: virtual_source_6_0_0
  id: virtual_source
  parameters:
    stream_id: Im_Ratio_LogMag
  states: {}

connections:
- [analog_sig_source_x_0_2, '0', blocks_float_to_complex_0_0, '0']
- [analog_sig_source_x_0_2, '0', qtgui_freq_sink_x_0_0_0_0_0_0_0, '0']
- [analog_sig_source_x_1, '0', qtgui_number_sink_2, '0']
- [blocks_add_xx_0_0_0, '0', blocks_divide_xx_0_0, '1']
- [blocks_add_xx_1, '0', virtual_sink_1_0_0, '0']
- [blocks_complex_to_float_0, '0', virtual_sink_1_1, '0']
- [blocks_complex_to_float_0, '1', virtual_sink_1_2, '0']
- [blocks_complex_to_float_0_0, '0', virtual_sink_1_1_0, '0']
- [blocks_complex_to_float_0_0, '1', virtual_sink_1_2_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_squared_0_1_0, '0', blocks_nlog10_ff_0_2, '0']
- [blocks_complex_to_mag_squared_0_1_0_0, '0', blocks_nlog10_ff_0_2_0, '0']
- [blocks_divide_xx_0_0, '0', virtual_sink_1_3, '0']
- [blocks_float_to_complex_0_0, '0', uhd_usrp_sink_0, '0']
- [blocks_freqshift_cc_0, '0', low_pass_filter_0, '0']
- [blocks_freqshift_cc_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_max_xx_1_0, '0', virtual_sink_7, '0']
- [blocks_max_xx_1_1_0, '0', virtual_sink_9, '0']
- [blocks_max_xx_1_1_0_0, '0', virtual_sink_10, '0']
- [blocks_message_strobe_0, strobe, epy_block_2, Ts]
- [blocks_moving_average_xx_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [blocks_multiply_const_xx_0_2, '0', virtual_sink_3, '0']
- [blocks_multiply_const_xx_0_2_0, '0', virtual_sink_4, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_add_xx_0_0_0, '1']
- [blocks_multiply_xx_0_0_1, '0', blocks_sub_xx_0, '1']
- [blocks_multiply_xx_0_1_0, '0', blocks_add_xx_0_0_0, '0']
- [blocks_multiply_xx_0_2, '0', blocks_sub_xx_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_max_xx_1_0, '0']
- [blocks_nlog10_ff_0_2, '0', blocks_max_xx_1_1_0, '0']
- [blocks_nlog10_ff_0_2_0, '0', blocks_max_xx_1_1_0_0, '0']
- [blocks_nlog10_ff_0_2_0, '0', virtual_sink_9_0, '0']
- [blocks_null_source_0, '0', uhd_usrp_sink_0, '1']
- [blocks_phase_shift_0, '0', virtual_sink_1_0_0_0, '0']
- [blocks_phase_shift_0_0, '0', virtual_sink_1_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_2, '0', fft_vxx_0_2, '0']
- [blocks_stream_to_vector_0_2_0, '0', fft_vxx_0_2_0, '0']
- [blocks_sub_xx_0, '0', blocks_divide_xx_0_0, '0']
- [blocks_sub_xx_2, '0', virtual_sink_1_0, '0']
- [epy_block_0, '0', epy_block_1_0, '0']
- [epy_block_1, '0', virtual_sink_2, '0']
- [epy_block_1_0, '0', epy_block_3_0, '0']
- [epy_block_1_0, '0', qtgui_number_sink_0, '0']
- [epy_block_1_0, '1', epy_block_3_0, '1']
- [epy_block_1_0, '2', epy_block_3_0, '2']
- [epy_block_1_0, '3', epy_block_3_0, '3']
- [epy_block_2, az, variable_qtgui_azelplot_0, azel]
- [epy_block_2, phase, virtual_sink_5, '0']
- [epy_block_2, steer_angle, analog_sig_source_x_1, cmd]
- [epy_block_3, out, virtual_sink_0, '0']
- [epy_block_3_0, out, blocks_msgpair_to_var_1, inpair]
- [fft_vxx_0_0, '0', blocks_multiply_const_xx_0_0, '0']
- [fft_vxx_0_2, '0', blocks_multiply_const_xx_0_2, '0']
- [fft_vxx_0_2_0, '0', blocks_multiply_const_xx_0_2_0, '0']
- [low_pass_filter_0, '0', blocks_phase_shift_0_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1, '0']
- [low_pass_filter_0_0, '0', blocks_phase_shift_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1, '1']
- [uhd_usrp_source_0, '0', blocks_freqshift_cc_0, '0']
- [uhd_usrp_source_0, '1', blocks_freqshift_cc_0_0, '0']
- [virtual_source_0, '0', blocks_phase_shift_0, shift]
- [virtual_source_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [virtual_source_0_0_0_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_0_1, '0', blocks_phase_shift_0, shift]
- [virtual_source_0_2, '0', blocks_moving_average_xx_0, '0']
- [virtual_source_0_2, '0', epy_block_0, '0']
- [virtual_source_1_0, '0', blocks_complex_to_float_0, '0']
- [virtual_source_1_0_0, '0', blocks_complex_to_float_0_0, '0']
- [virtual_source_1_0_0_1, '0', blocks_stream_to_vector_0_2_0, '0']
- [virtual_source_1_0_0_2, '0', blocks_add_xx_1, '1']
- [virtual_source_1_0_0_2, '0', blocks_sub_xx_2, '1']
- [virtual_source_1_0_0_3, '0', blocks_add_xx_1, '0']
- [virtual_source_1_0_0_3, '0', blocks_sub_xx_2, '0']
- [virtual_source_1_0_2, '0', blocks_stream_to_vector_0_2, '0']
- [virtual_source_1_1_0_0_0, '0', blocks_multiply_xx_0_1_0, '1']
- [virtual_source_1_1_0_1_0, '0', blocks_multiply_xx_0_1_0, '0']
- [virtual_source_1_1_0_2, '0', blocks_multiply_xx_0_2, '1']
- [virtual_source_1_1_1, '0', blocks_multiply_xx_0_2, '0']
- [virtual_source_1_2_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [virtual_source_1_2_0_1_0, '0', blocks_multiply_xx_0_0_0_0, '1']
- [virtual_source_1_2_0_2, '0', blocks_multiply_xx_0_0_1, '1']
- [virtual_source_1_2_1, '0', blocks_multiply_xx_0_0_1, '0']
- [virtual_source_1_3, '0', epy_block_2, '1']
- [virtual_source_1_4, '0', epy_block_3, '3']
- [virtual_source_2, '0', epy_block_1, '0']
- [virtual_source_2_0, '0', blocks_complex_to_mag_squared_0_1_0, '0']
- [virtual_source_3, '0', epy_block_1, '1']
- [virtual_source_3_0, '0', blocks_complex_to_mag_squared_0_1_0_0, '0']
- [virtual_source_5_0, '0', epy_block_3, '1']
- [virtual_source_5_0_0, '0', epy_block_3, '0']
- [virtual_source_6_0, '0', epy_block_3, '2']
- [virtual_source_6_0_0, '0', epy_block_2, '0']

metadata:
  file_format: 1
